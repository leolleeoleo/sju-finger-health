# Keil uVision project HealthMicroprocessor.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: HealthMicroprocessor +hex
  c flags: Optimize=8 SizeSpeed=1
  group MAIN
    ./: STARTUP.A51
    ./src/: base.c interrupt.c main.c iap.asm configuration.c
  group LCD
    ./src/: flash.c lcd.c ra8806.c keyboard.c
  group FingerPrint
    ./src/: tfs_m51.c
  group STATE
    ./src/: state.c configure.c
  group UART
    ./src/: spi.c uart.c sc16is752.c
  group GPRS
    ./src/: sim300.c client.c
